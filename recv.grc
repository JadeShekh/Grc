options:
  parameters:
    author: jade
    generate_options: qt_gui
    id: recv
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '8000'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_source_1
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '8000'
    psize: '1472'
    type: float
    vlen: '1'
  states: {}

connections:
- [blocks_udp_source_0, '0', audio_sink_0, '0']
- [blocks_udp_source_1, '0', audio_sink_0, '0']

metadata:
  file_format: 1
